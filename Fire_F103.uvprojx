# Keil uVision project Fire_F103.uvprojx, settings and files
target 饮水机 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --locale=english
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../User/: system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c flo.c flo.h
    ../User/led/: bsp_gpio_led.c
    ../User/key/: bsp_gpio_key.c
    ../User/delay/: bsp_delay.c
    ../User/dwt/: bsp_dwt.c bsp_dwt.h
    ../User/i2c/: bsp_i2c.c bsp_i2c.h
    ../User/oled/: bsp_i2c_oled.c bsp_i2c_oled.h
    ../User/debug/: bsp_debug.c bsp_debug.h
    ../User/usart/: usart_com.c usart_com.h
    ../User/fonts/: bsp_fonts.c bsp_fonts.h
    ../User/TDS/: tds.c tds.h
    ../User/adc/: adcx.c adcx.h
    ../User/DS18B20/: ds18b20.c ds18b20.h
    ../User/sys/: sys.c sys.h
    ../User/usart3/: usart3.c usart3.h
